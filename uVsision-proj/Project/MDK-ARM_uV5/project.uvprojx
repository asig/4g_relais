# Keil uVision project project.uvprojx, settings and files
target Flash (6230000::V6.23::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 4g_relais +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32F103x6
  c include: ..\..\User\bsp\inc;..\..\User;..\..\Libraries\STM32F1xx_HAL_Driver\Inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\Libraries\CMSIS\Device\ST\STM32F1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ../../User/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c air780e.c
  group BSP
    ../../User/bsp/: bsp.c
    ../../User/bsp/src/: bsp_key.c bsp_timer.c bsp_uart_fifo.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103x6.s
  group HAL_Driver
    ../../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c
  group CMSIS
    ../../User/: system_stm32f1xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
